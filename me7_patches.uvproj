# Keil uVision project me7_patches.uvproj, settings and files
target Target 1 (166/167)
  device: C167CS-LM Infineon
  cpu: IRAM(0xF200-0xFDFF) XRAM(0xE000-0xE7FF) XRAM2 (0xC000-0xD7FF) ICAN(0xE800-0xEFFF) CLOCK(25000000) MOD167
  output: me7_patches +hex
  group Source Group 1
    ./: main.c
